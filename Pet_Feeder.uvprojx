# Keil uVision project Pet_Feeder.uvprojx, settings and files
target Pet_Feeder (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pet_Feeder +hex
  c flags: uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CORE;.\Hardware\led;.\Hardware\motor;.\Hardware\tuya;.\Libraries\inc;.\User;.\User\sys;.\User\SysTick;.\System\usart;.\System\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c system_stm32f10x.c system.c
    ./User/sys/: sys.c
    ./User/SysTick/: bsp_SysTick.c
  group Hardware
    ./Hardware/led/: bsp_led.c
    ./Hardware/motor/: bsp_motor.c bsp_motor0.c
    ./Hardware/tuya/: mcu_api.c protocol.c
  group Core
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group System
    ./System/usart/: usart.c
  group Libraries
    ./Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
